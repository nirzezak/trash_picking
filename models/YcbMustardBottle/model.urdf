Commit message: Creating branch for the POC that was presented in class

File: models/YcbMustardBottle/model.urdf (robot description, URDF)
Before this commit: robot model.urdf, 1 links, 0 joints
Links:
- link baseLink: mass .603 -> .1
